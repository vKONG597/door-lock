# IAR project project.ewp, settings and files
configuration STM8L15X_MD(STM8L15xx4_6) (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD; USE_STM8L1526_EVAL
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8_EVAL; ..\..\..\Utilities\STM8_EVAL\STM8L1526_EVAL; ..\..\..\Utilities\STM8_EVAL\Common; ..\..\..\Utilities\Misc; ..\..\..\Source\Driver; ..\..\..\Source\User; ..\..\..\Source\User\dateTime; ..\..\..\Source\User\menu; ..\..\..\Source\User\menu\SystemSetting; ..\..\..\Source\User\menu\UserManager
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM8L15X_HD(STM8L15xx8_16xx8) (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L152M8 STM8L152M8
  General.GenCodeModel: 2
  ICCSTM8.CCDefines: USE_STM8L1528_EVAL; STM8L15X_HD
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8_EVAL; ..\..\..\Utilities\STM8_EVAL\STM8L1528_EVAL; ..\..\..\Utilities\STM8_EVAL\Common; ..\..\..\Utilities\Misc
configuration STM8L15X_LD(STM8L15xx2_3) (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L151C3 STM8L151C3
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L15X_LD
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8_EVAL; ..\..\..\Utilities\STM8_EVAL\STM8L1526_EVAL; ..\..\..\Utilities\STM8_EVAL\Common; ..\..\..\Utilities\Misc
configuration STM8L05X_LD_VL(STM8L05xx3) (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L05X_LD_VL
  ICCSTM8.CCIncludePath2: as above
configuration STM8L05X_MD_VL(STM8L05xx6) (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L052C6 STM8L052C6
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L05X_MD_VL
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8_EVAL; ..\..\..\Utilities\STM8_EVAL\STM8L1526_EVAL; ..\..\..\Utilities\STM8_EVAL\Common; ..\..\..\Utilities\Misc; C:\Users\12633\Desktop\门禁系统\debugModule\Source\driver; C:\Users\12633\Desktop\门禁系统\debugModule\Source\User; C:\Users\12633\Desktop\门禁系统\debugModule\Source\User\menu
configuration STM8L05X_HD_VL(STM8L05xx8) (STM8, debug)
  as the first configuration, except:
  General.GenCodeModel: 2
  ICCSTM8.CCDefines: USE_STM8L1528_EVAL; STM8L05X_HD_VL
  ICCSTM8.CCIncludePath2: as above
  group driver
    ../../../Source/driver/: board.c board.h keys.c keys.h oled.c oled.h
  group STM8L15x_StdPeriph_Driver
    ../../../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group User
    ../../../Source/User/: gpio.c main.c rtc.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h timer4.c usart.c
  group User/menu
    ../../../Source/User/menu/: EventManager.c EventManager.h MainMenu.c MainMenu.h SystemParameters.c SystemParameters.h
